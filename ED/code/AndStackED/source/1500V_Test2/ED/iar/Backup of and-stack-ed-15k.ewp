# IAR project Backup of and-stack-ed-15k.ewp, settings and files
configuration Debug on CC1110 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2511.i51
  ICC8051.CCDefines: chip=2510
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CODE\AndStackED\INCLUDE; ..\CODE\LIBRARY\HAL\INCLUDE; ..\CODE\LIBRARY\HAL_BUI\INCLUDE
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  A8051.ADefines: chip=1110
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1110.xcl
configuration Build .hex for CC1110 (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC1110.i51
  ICC8051.CCDefines: chip=1110
configuration Debug on CC2510 (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2510.i51
  A8051.ADefines: chip=2510
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
configuration Build .hex for CC2510 (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2510.i51
  ICC8051.CCDefines: NDEBUG; chip=2510
  A8051.ADefines: chip=2510
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510-15k.xcl
  group (top)
    ../code/AndStackED/source/: aes.c dma.c flash.c flashDmaTrigger.s51 hop.c main.c radio.c
  group hal
    ../code/Library/HAL/source/: hal_power_clk_mgmt.c hal_wait.c
