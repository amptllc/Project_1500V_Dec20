# IAR project rx_print_RevC_compatible.ewp, settings and files
configuration Debug on CC2510 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2510.i51
  ICC8051.CCDefines: chip=2510
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CODE\PER_TEST\INCLUDE; ..\CODE\LIBRARY\HAL\INCLUDE; ..\CODE\LIBRARY\HAL_BUI\INCLUDE
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  A8051.ADefines: chip=2510
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
configuration Build .hex for CC2510 (8051)
  as the first configuration, except:
  ICC8051.CCIncludePath2: ..\CODE\LIBRARY\HAL\INCLUDE; ..\CODE\LIBRARY\HAL_BUI\INCLUDE; ..\CODE\Gateway\INCLUDE; ..\CODE\LIBRARY\RfUsbLibrary; ..\CODE\LIBRARY\RfUsbLibrary\Include; ..\CODE\LIBRARY\RfAppExLibrary
configuration Build .hex for CC2511 Dongle (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2511.i51
  ICC8051.CCDefines: chip=2511; RF_FREQUENCY=2433000; RevC; No_Lobotomy
  ICC8051.CCIncludePath2: ..\CODE\gateway\INCLUDE; ..\CODE\LIBRARY\HAL\INCLUDE; ..\CODE\LIBRARY\HAL_BUI\INCLUDE; ..\CODE\LIBRARY\EB\INCLUDE; ..\CODE\LIBRARY\RFUSBLIBRARY; ..\CODE\LIBRARY\RFAPPEXLIBRARY
  A8051.ADefines: chip=2511
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2511.xcl
  group (top)
    ../code/gateway/source/: aes.c dma.c flash.c flashDmaTrigger.s51 hop.c main.c radio.c usb.c
  group hal
    ../code/Library/HAL/source/: hal_adc_mgmt.c hal_power_clk_mgmt.c util_critical_section.s51 wait.c
  group usb
    ../code/gateway/source/: usb_descriptor.s51
    ../code/Library/RfUsbLibrary/source/: usb_descriptor_parser.c usb_framework.c usb_interrupt.c usb_standard_requests.c usb_suspend.c
